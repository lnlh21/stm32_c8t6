# IAR project ministm32_app.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\; ..\..\; ..\..\src; ..\..\src\bsp; ..\..\src\driver; ..\..\src\Eth; ..\..\src\Eth\stm32; ..\..\src\Eth\lwip-1.3.1\src\include\; ..\..\src\Eth\lwip-1.3.1\src\include\lwip; ..\..\src\Eth\lwip-1.3.1\src\include\ipv4\; ..\..\src\Eth\lwip-1.3.1\src\include\netif\; ..\..\src\uCOS-II; ..\..\src\uCOS-II\Ports; ..\..\src\uCOS-II\Source; ..\..\src\VOS\include; ..\..\src\VOS\cmd; ..\..\src\usb; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\STM32_USB-FS-Device_Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ministm32_app.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../../src/: main.h
  group Lib/CMSIS
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Lib/EWARM
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group Lib/StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group UCOS
    ../../src/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../../src/uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group User
    ../../src/: cmdtree.c main.c
  group User/bsp
    ../../src/bsp/: bsp.c stm32f10x_it.c
  group User/drv
    ../../src/drv/: drv_nrf24l01.c drv_nrf24l01.h
  group User/vos/cmd
    ../../src/vos/cmd/: vos_cmd.c vos_cmd.h
