# IAR project Backup of ministm32_app.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\; ..\..\; ..\..\src; ..\..\src\driver; ..\..\src\Eth; ..\..\src\Eth\stm32; ..\..\src\Eth\lwip-1.3.1\src\include\; ..\..\src\Eth\lwip-1.3.1\src\include\lwip; ..\..\src\Eth\lwip-1.3.1\src\include\ipv4\; ..\..\src\Eth\lwip-1.3.1\src\include\netif\; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\STM32_USB-FS-Device_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ministm32_app.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group Driver
    ../../src/driver/: drv_enc28j60.c drv_enc28j60.h drv_flash.c drv_flash.h drv_init.c drv_init.h drv_interrupt.c drv_interrupt.h drv_spi.c drv_spi.h drv_usart.c drv_usart.h drv_usb.c drv_usb.h drv_util.c drv_util.h
  group Lib/CMSIS
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Lib/EWARM
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group Lib/StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group Lib/USB_Driver
    ../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group User
    ../../src/: CMD_Main.c CMD_Main.h cmd_net.c cmd_net.h hw_config.c hw_config.h ip_arp_udp_tcp.c ip_arp_udp_tcp.h main.c main.h net.h platform_config.h public_def.h simple_server.c simple_server.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h usb_conf.h usb_desc.c usb_desc.h usb_endp.c usb_istr.c usb_istr.h usb_prop.c usb_prop.h usb_pwr.c usb_pwr.h
  group User/ETH
    ../../src/Eth/: eth_api.c eth_api.h
    ../../src/Eth/stm32/: eth_drv.c eth_drv.h Eth_Mid.c eth_mid.h eth_srv.c eth_srv.h ethernetif.c ethernetif.h
  group User/ETH/Lwip
    ../../src/Eth/lwip-1.3.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c tcpip.c
    ../../src/Eth/lwip-1.3.1/src/core/ipv4/: autoip.c icmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../src/Eth/lwip-1.3.1/src/netif/: etharp.c
    ../../src/Eth/stm32/: lwipopts.h
    ../../src/Eth/lwip-1.3.1/src/core/: mem.c memp.c netif.c pbuf.c raw.c sys.c udp.c
